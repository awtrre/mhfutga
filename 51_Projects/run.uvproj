# Keil uVision project run.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: run +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c motor.h motor.c buttons.h buttons.c eeprom.h eeprom.c onekey.h onekey.c hcsr04.h hcsr04.c buzzer.h buzzer.c uart.c uart.h
